# Keil uVision project RFtester.uvprojx, settings and files
target STM32L151 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L152RE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x14000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RFtester +hex
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32L1XX_MD
  c misc: --c99
  c include: .\CMSIS\Include;.\CMSIS\Device\ST\STM32L1xx\Include;.\Header;.\STM32L1xx_StdPeriph_Driver_v1_2\inc;.\Tests;.\USER_HEAD_file_2;.\Crypt;.\Modbus;.\STM32L1xx_StdPeriph_Driver_v1_2\inc;.\usb\inc;.\gsm\gsm_head;.\WizFi;.\Ethernet;.\display;.\gsm\inc;.\ListLib\inc;.\Menu\inc;.\system\inc;.\eeprom\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  group Start
    ./: startup_stm32l1xx_md.s
    ./CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
  group User
    ./User_SRC_file/: main.c eeprom.c gpio.c RFM69.c spi.c stm32l1xx_it.c testmode.c timers.c uart.c uart_commands.c myusb.c
  group Start_Header
    ./Header/: stm32l1xx_conf.h
    ./CMSIS/Device/ST/STM32L1xx/Include/: stm32l1xx.h system_stm32l1xx.h
    ./CMSIS/Include/: core_cm3.h
  group SPLD_v_1_2_0
    ./STM32L1xx_StdPeriph_Driver_v1_2/src/: misc.c stm32l1xx_rcc.c stm32l1xx_exti.c stm32l1xx_syscfg.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group usb_src
    ./usb/src/: usb_config.c usb_endp.c usb_func.c usb_init.c usb_interrupt.c usb.c
  group usb_head
    ./usb/inc/: type.h usb.h usb_endp.h usb_func.h usb_init.h usb_interrupt.h
