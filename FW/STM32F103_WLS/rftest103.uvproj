# Keil uVision project rftest103.uvproj, settings and files
target stm32F103 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: rftest103
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: .\include;.\source;.\startup;.\std_lib\inc;.\std_lib\src
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group src
    ./source/: eeprom.c gpio.c main.c RFM69.c spi.c testmode.c timers.c uart.c uart_commands.c
  group inc
    ./include/: eeprom.h gpio.h macro.h main.h mysettings.h RFM69.h spi.h stm32f0xx_conf.h stm32l1xx_it.h testmode.h timers.h uart.h uart_commands.h user_settings.h
  group SPL
    ./std_lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ./include/: eeprom.h gpio.h macro.h main.h mysettings.h RFM69.h spi.h stm32f0xx_conf.h stm32l1xx_it.h testmode.h timers.h uart.h uart_commands.h user_settings.h
  group CMSIS
    ./startup/: core_cm3.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_md.s
