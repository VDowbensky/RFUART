# Keil uVision project rftest051.uvproj, settings and files
target stm32f051 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F051K8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: rftest030
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F030,USE_DEFAULT_TIMEOUT_CALLBACK
  c include: .\source;.\include;.\STM32F0xx_StdPeriph_Driver\src;.\STM32F0xx_StdPeriph_Driver\inc;.\CMSIS\Include;.\CMSIS\Device\ST\STM32F0xx\Include;.\CMSIS\Device\ST\STM32F0xx\Source\Templates\arm
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source
    ./source/: eeprom.c gpio.c main.c RFM69.c spi.c testmode.c timers.c uart.c uart_commands.c
  group Include
    ./include/: eeprom.h gpio.h macro.h main.h mysettings.h RFM69.h spi.h stm32f0xx_conf.h stm32l1xx_it.h testmode.h timers.h uart.h uart_commands.h user_settings.h
  group SPL
    ./STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
    ./STM32F0xx_StdPeriph_Driver/inc/: stm32f0xx_adc.h stm32f0xx_can.h stm32f0xx_cec.h stm32f0xx_comp.h stm32f0xx_crc.h stm32f0xx_crs.h stm32f0xx_dac.h stm32f0xx_dbgmcu.h stm32f0xx_dma.h stm32f0xx_exti.h stm32f0xx_flash.h stm32f0xx_gpio.h stm32f0xx_i2c.h stm32f0xx_iwdg.h stm32f0xx_misc.h stm32f0xx_pwr.h stm32f0xx_rcc.h stm32f0xx_rtc.h stm32f0xx_spi.h stm32f0xx_syscfg.h stm32f0xx_tim.h stm32f0xx_usart.h stm32f0xx_wwdg.h
  group CMSIS
    ./CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
    ./CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f051.s
