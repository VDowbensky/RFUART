# IAR project project.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L051F3 STM8L051F3
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L15X_LD
  ICCSTM8.CCIncludePath2: D:\Projects\Lab equipment\RFUART\FW\STM8L_IAR; D:\Projects\Lab equipment\RFUART\FW\STM8L_IAR\src; D:\Projects\Lab equipment\RFUART\FW\STM8L_IAR\inc; D:\Projects\Lab equipment\RFUART\FW\STM8L_IAR\STM8L15x_StdPeriph_Driver\src; D:\Projects\Lab equipment\RFUART\FW\STM8L_IAR\STM8L15x_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: sender.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCIncludePath2: D:\Projects\Lab equipment\RFUART\FW\IAR; D:\Projects\Lab equipment\RFUART\FW\IAR\src; D:\Projects\Lab equipment\RFUART\FW\IAR\inc; D:\Projects\Lab equipment\RFUART\FW\IAR\STM8L15x_StdPeriph_Driver\src; D:\Projects\Lab equipment\RFUART\FW\STM8L_IAR\STM8L15x_StdPeriph_Driver; D:\Projects\Lab equipment\RFUART\FW\STM8L_IAR\STM8L15x_StdPeriph_Driver\inc; D:\Projects\Lab equipment\RFUART\FW\STM8L_IAR\inc
  group Libraries/inc
    inc/: macro.h main.h
    STM8L15x_StdPeriph_Driver/inc/: stm8l15x.h stm8l15x_adc.h stm8l15x_aes.h stm8l15x_beep.h stm8l15x_clk.h stm8l15x_comp.h stm8l15x_dac.h stm8l15x_dma.h stm8l15x_exti.h stm8l15x_flash.h stm8l15x_gpio.h stm8l15x_i2c.h stm8l15x_irtim.h stm8l15x_itc.h stm8l15x_iwdg.h stm8l15x_lcd.h stm8l15x_pwr.h stm8l15x_rst.h stm8l15x_rtc.h stm8l15x_spi.h stm8l15x_syscfg.h stm8l15x_tim1.h stm8l15x_tim2.h stm8l15x_tim3.h stm8l15x_tim4.h stm8l15x_tim5.h stm8l15x_usart.h stm8l15x_wfe.h stm8l15x_wwdg.h
  group Libraries/src
    STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
  group User/inc
    inc/: eep.h eeprom.h gpio_interface.h RFM69.h spi_interface.h stm8l15x_conf.h stm8l15x_it.h testmode.h uart_commands.h uart_interface.h user_settings.h
  group User/src
    src/: eep.c eeprom.c gpio_interface.c main.c RFM69.c spi_interface.c stm8l15x_it.c testmode.c uart_commands.c uart_interface.c
